Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-07-03T16:51:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 03 16:51:07 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\2078e45b-b24e-45f9-b594-959663585b18\969d4e41-bc84-4cbf-8470-fd4fd8b19af5\ifc * Database version: 5507 * Database creation date: Wed Jul 03 16:51:07 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 03 16:51:07 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 03 16:51:07 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: DH320.600, DH320:DH320.600:348326
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 64 mm; Length: 600 mm; Width: 19 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_30_36_59_64 Pull handles; CAWS: P21/641 Pull handles; CodePerformance: n/a; Color: Various; Constituents: n/a; Description: Pull handle; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Satin_suffix_.5PowderCoated_.6CeramicCoated; Form: Door-mounted; Grade: 316; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: Stainless steel; ModelNumber: DH320.600_suffix.5PowderCoated_.6CeramicCoated; ModelReference: DolphinSolutionsLimited_PillarDoorPullHandle; Name: PillarDoorPullHandle_DH320.600_DolphinSolutionsLimited; NBSDescription: Pull handles; NBSTypeID: n/a; NominalDepth: 64; NominalLength: 600; NominalWidth: 19; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 64x600x19; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DH320.600; Uniclass2015Code: Pr_30_36_59_64; Uniclass2015Title: Pull handles; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Generic Models; Family Name: DH320
Type - Pset_BuildingElementProxyCommon - Reference: DH320:DH320.600
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_PillarDoorPullHandle; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: PillarDoorPullHandle_DH320.600_DolphinSolutionsLimited; Category: Pr_30_36_59_64 Pull handles
Type - Pset_QuantityTakeOff - Reference: DH320:DH320.600
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Generic Models
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.0210051 m2; Volume: 0.000196439 m3
Other - Family: DH320: DH320.600; Family and Type: DH320: DH320.600; Type: DH320: DH320.600; Type Id: DH320: DH320.600
Phasing - Phase Created: New Construction
